# Keil uVision project APOLLP_NAND_FLASH_FLM.uvprojx, settings and files
target STM32H743I-eval_FMC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: APOLLO_NAND_FLASH
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32H743xx,USE_STM32H743I_EVAL,USE_IOEXPANDER
  c include: ./;C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\Drivers\CMSIS\Include;.\CMSIS;.\FMC
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group FMC
    ./FMC/: STM32H7FMC.c stm32h7xxfmc.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_msp.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_it.c stm32h7xx_ll_fmc.c system_stm32h7xx.c stm32h7xx_hal_nand.c
